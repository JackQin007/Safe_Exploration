Commit message: update the urdf

File: ISSAC-ENV/IsaacGymEnvs/assets/urdf/mobile_base_urdf/model/simple_mobile_kinova.urdf (robot description, URDF)
Before this commit: robot mobile, 32 links, 31 joints
Links:
- removed link robotiq_base_link
